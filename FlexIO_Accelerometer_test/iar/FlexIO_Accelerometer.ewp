# IAR project FlexIO_Accelerometer.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK82FN256xxx15 Freescale MK82FN256xxx15
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: DEBUG; CPU_MK82FN256VLL15
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\../devices/MK82F25615; ..\..\..\..\../devices/MK82F25615/utilities; ..\..\..\..\../devices/MK82F25615/drivers; ..\..\..\..\../devices/MK82F25615/iar; ..\..\..\..\../CMSIS/Include; ../../..; ../
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: FlexIO_Accelerometer.out
  ILINK.IlinkIcfFile: MK82FN256xxx15_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MK82FN256VLL15
  ICCARM.CCOptLevel: 3
  group (top)
    ./: MK82FN256xxx15_flash.icf
  group startup
    ../../../../../devices/MK82F25615/iar/: startup_MK82F25615.s
    ../../../../../devices/MK82F25615/: system_MK82F25615.c system_MK82F25615.h
  group CMSIS
    ../../../../../CMSIS/Include/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h cmsis_armcc_V6.h cmsis_gcc.h core_cmFunc.h core_cmInstr.h core_cmSimd.h core_cm4.h
    ../../../../../devices/MK82F25615/: fsl_device_registers.h MK82F25615.h MK82F25615_features.h
  group board
    ../: board.c board.h pin_mux.c pin_mux.h clock_config.c clock_config.h
  group drivers
    ../../../../../devices/MK82F25615/drivers/: fsl_sdhc.c fsl_sdhc.h fsl_dspi.c fsl_dspi_edma.c fsl_dspi.h fsl_dspi_edma.h fsl_rcm.c fsl_rcm.h fsl_flash.c fsl_flash.h fsl_tpm.c fsl_tpm.h fsl_lpuart.c fsl_lpuart_edma.c fsl_lpuart.h fsl_lpuart_edma.h fsl_crc.c fsl_crc.h fsl_pmc.c fsl_pmc.h fsl_lptmr.c fsl_lptmr.h fsl_smc.c fsl_smc.h fsl_smartcard_emvsim.c fsl_smartcard_emvsim.h fsl_wdog.c fsl_wdog.h fsl_flexio.c fsl_flexio_camera.c fsl_flexio_camera_edma.c fsl_flexio_i2c_master.c fsl_flexio_i2s.c fsl_flexio_i2s_edma.c fsl_flexio_spi.c fsl_flexio_spi_edma.c fsl_flexio_uart.c fsl_flexio_uart_edma.c fsl_flexio.h fsl_flexio_camera.h fsl_flexio_camera_edma.h fsl_flexio_i2c_master.h fsl_flexio_i2s.h fsl_flexio_i2s_edma.h fsl_flexio_spi.h fsl_flexio_spi_edma.h fsl_flexio_uart.h fsl_flexio_uart_edma.h fsl_mpu.c fsl_mpu.h fsl_cmp.c fsl_cmp.h fsl_sdramc.c fsl_sdramc.h fsl_rtc.c fsl_rtc.h fsl_i2c.c fsl_i2c_edma.c fsl_i2c.h fsl_i2c_edma.h fsl_flexbus.c fsl_flexbus.h fsl_dac.c fsl_dac.h fsl_port.h fsl_edma.c fsl_edma.h fsl_clock.c fsl_clock.h fsl_vref.c fsl_vref.h fsl_ftm.c fsl_ftm.h fsl_pdb.c fsl_pdb.h fsl_llwu.c fsl_llwu.h fsl_cmt.c fsl_cmt.h fsl_sim.c fsl_sim.h fsl_adc16.c fsl_adc16.h fsl_smartcard_phy_emvsim.c fsl_smartcard_phy_emvsim.h fsl_sai.c fsl_sai_edma.c fsl_sai.h fsl_sai_edma.h fsl_qspi.c fsl_qspi_edma.c fsl_qspi.h fsl_qspi_edma.h fsl_dmamux.c fsl_dmamux.h fsl_smartcard_phy_ncn8025.c fsl_smartcard_phy_ncn8025.h fsl_ewm.c fsl_ewm.h fsl_gpio.c fsl_gpio.h fsl_pit.c fsl_pit.h fsl_common.c fsl_common.h fsl_lmem_cache.c fsl_lmem_cache.h fsl_ltc.c fsl_ltc_edma.c fsl_ltc.h fsl_ltc_edma.h fsl_smartcard.h fsl_tsi_v4.c fsl_tsi_v4.h fsl_trng.c fsl_trng.h
  group utilities
    ../../../../../devices/MK82F25615/utilities/: fsl_debug_console.c fsl_debug_console.h fsl_notifier.c fsl_notifier.h fsl_sbrk.c
  group sources
    ../: main.c main.h
